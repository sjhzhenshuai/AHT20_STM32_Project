# Keil uVision project Task2_AHT20.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(72000000) ESEL ELITTLE
  output: Task2_AHT20 +hex
  c flags: Optim=2 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=5 wLevel=3
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,SYS_SUPPORT_OS,__TARGET_FPU_SOFTVFP
  c misc: -Wno-unused-command-line-argument
  c include: .\User;.\CMSIS;.\StdPeriph_Driver\inc;.\Hardware;.\Middlewares;.\Middlewares\uC-OS2\uC-CPU;.\Middlewares\uC-OS2\uC-CPU\Cfg\Template;.\Middlewares\uC-OS2\uC-CPU\ARM-Cortex-M\ARMv7-M\ARM;.\Middlewares\uC-OS2\uC-LIB;.\Middlewares\uC-OS2\uC-LIB\Cfg\Template;.\Middlewares\uC-OS2\uC-OS2\Cfg\Template;.\Middlewares\uC-OS2\uC-OS2\Ports\ARM-Cortex-M\ARMv7-M\ARM;.\Middlewares\uC-OS2\uC-OS2\Source;..\Common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s cmsis_version.h cmsis_compiler.h
  group StdPeriph_Driver
    ./StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c misc.c stm32f10x_i2c.c
  group User
    ./User/: main.c app_hooks.c
  group Hardware
    ./Hardware/: delay.c usart.c led.c
  group uC-OS-II
    ./Middlewares/uC-OS2/uC-CPU/: cpu_core.c
    ./Middlewares/uC-OS2/uC-CPU/ARM-Cortex-M/ARMv7-M/: cpu_c.c
    ./Middlewares/uC-OS2/uC-CPU/ARM-Cortex-M/ARMv7-M/ARM/: cpu_a.asm
    ./Middlewares/uC-OS2/uC-OS2/Source/: ucos_ii.c os_dbg_r.c
    ./Middlewares/uC-OS2/uC-OS2/Ports/ARM-Cortex-M/ARMv7-M/: os_cpu_c.c
    ./Middlewares/uC-OS2/uC-OS2/Ports/ARM-Cortex-M/ARMv7-M/ARM/: os_cpu_a.asm
    ./Middlewares/uC-OS2/uC-LIB/: lib_mem.c lib_str.c lib_ascii.c
  group Common
    ../Common/: i2c.c i2c_soft.c i2c_hw.c aht20.c i2c.h aht20.h
software components: CMSIS:CORE 5.6.0
